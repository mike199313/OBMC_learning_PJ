FILESEXTRAPATHS:prepend:starscream := "${THISDIR}/${PN}:"

SRC_URI += "file://fstab \
        "
