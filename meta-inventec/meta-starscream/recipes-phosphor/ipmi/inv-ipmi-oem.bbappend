PACKAGECONFIG:append:starscream = " bios-oem ast"
