EXTRA_OEMESON:append = " -Ddefault-nic='eth1'"

