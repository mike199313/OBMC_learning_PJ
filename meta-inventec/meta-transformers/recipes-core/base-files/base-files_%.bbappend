FILESEXTRAPATHS:prepend:transformers := "${THISDIR}/${PN}:"

SRC_URI += "file://fstab \
        "
