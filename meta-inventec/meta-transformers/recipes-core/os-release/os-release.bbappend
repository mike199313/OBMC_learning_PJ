# Machine name for release
# S [CPU] [BMC] [Serial]
# [CPU]: 1 ARM, 2 Intel, 3 AMD
# [BMC]: 1 Aspeed, 2 Nuvton
MACHINE_NAME = "Transformers"
PLATFORM_ID = "S2100"
