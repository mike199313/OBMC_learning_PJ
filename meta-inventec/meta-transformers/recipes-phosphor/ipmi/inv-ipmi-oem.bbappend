PACKAGECONFIG:append:transformers = " bios-oem ast"
