FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Fix-reboot-message-missing-when-graceful-reset-from-.patch"

