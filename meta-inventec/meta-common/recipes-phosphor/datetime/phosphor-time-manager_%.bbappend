FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI +=  " \
            file://0001-Bug-588-Transformers-OpenBMC-Y2K38-problem.patch \
            "

