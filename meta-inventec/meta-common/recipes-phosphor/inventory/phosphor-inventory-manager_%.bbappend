FILESEXTRAPATHS:append := "${THISDIR}/${PN}:"

SRC_URI:append = " file://0001-Modify-Notify-function-allow-new-value-types-as-inpu.patch \
"
