FILESEXTRAPATHS:append := "${THISDIR}/${PN}:"

SRC_URI:append = " file://0001-Workaround-for-nscd-monitor-file-path-incorrect-issu.patch \
"

