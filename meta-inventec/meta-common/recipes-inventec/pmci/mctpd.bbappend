SRC_URI += "file://0001-fix-build-error-for-mctpd.patch"
SRC_URI += "file://0002-Custom-modification-of-ACC100-for-MCTPD.patch"
