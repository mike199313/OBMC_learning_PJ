FILESEXTRAPATHS:prepend:transformers-nuv := "${THISDIR}/${PN}:"

SRC_URI += "file://fstab \
        "
