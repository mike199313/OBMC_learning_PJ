FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-support-smbios-with-pcimbox-on-nuvoton.patch"

