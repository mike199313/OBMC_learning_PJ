FILESEXTRAPATHS:prepend:transformers-nuv := "${THISDIR}/${PN}:"

#SRC_URI:append:transformers-nuv = " file://0028-MCTP-Daemon-D-Bus-interface-definition.patch"
SRC_URI:append:transformers-nuv = " file://0001-Software-Add-MCU-VersionPurpose.patch"
