PACKAGECONFIG:append:transformers-nuv = " bios-oem nuv"
